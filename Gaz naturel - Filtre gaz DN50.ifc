Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:17:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:17:20 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{62D34081-5D19-4B25-BF74-CE44324F0C4F}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:17:18 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:17:18 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:17:18 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: DN 50, Gaz naturel – Filtre gaz:DN 50:206217
In: Niveau 1
Type - Material: Métal
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Filtre gaz
Type - Données d'identification(Type) - Nom du type: DN 50
Pset_DistributionFlowElementCommon - Reference: DN 50
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Filtre gaz: DN 50; Famille et type: Gaz naturel – Filtre gaz: DN 50; ID du type: Gaz naturel – Filtre gaz: DN 50; Type: Gaz naturel – Filtre gaz: DN 50
Contraintes - Décalage: 0 mm; Diamétre C: 165 mm; DN: 50 mm; Hauteur B: 110 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Longueur A: 160 mm; Matériau: Métal; Niveau: Niveau: Niveau 1; Pression max: 0 Pa; Température max: 0 kg/K/s3; Température min: 0 kg/K/s3
Cotes - Débord: 337.143 mm; DEBORD10: 10 mm; Debord2: 40 mm; Debord3: 50 mm; DEBORD4: 217.143 mm; DIAM 2: 90 mm; DIAM 3: 55 mm; DIAM 5: 18.3333 mm; DN Bloque: 50 mm; RAY 3: 27.5 mm; Surface: 0.0791835 m2; Taille: 50 mmø-50 mmø; Taille maximale: 50 mm; Taille minimale: 50 mm; Volume: 0.00279333 m3
Données d'identification - Identifiant: 16
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-50 mmø
Phase de construction - Phase de création: Nouvelle construction
